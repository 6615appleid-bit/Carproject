# Keil uVision project CarProject.uvprojx, settings and files
target CarControl_Hardware_STM32F103C8 (5060528::V5.06 update 5 (build 528)::ARMCC)
  device: STM32F103C8 STMicroelectronics
  pack: Keil.STM32F1xx_DFP.2.3.0
  cpu: IRAM(0x20000000,0x5000) IROM(0x08000000,0x10000) CPUTYPE("Cortex-M3") CLOCK(72000000) ELITTLE
  output: CarControl_Hardware +hex
  c flags: Optim=1 uC99=1 v6Lang=1 v6LangP=1
  c define: STM32F10X_MD,USE_STDPERIPH_DRIVER
  c include: ..\App;..\Modules;..\Drivers;..\Hardware;..\Platform;..\User;..\Libraries\CMSIS;..\Libraries\STM32F10x_StdPeriph_Driver\inc
  memory RVCT4: ROM 0x8000000 size 0x10000
  memory RVCT9: RAM 0x20000000 size 0x5000
  group App
    ../App/: CarControl.c CarControl.h CarConfig.h
  group User
    ../User/: main.c stm32f10x_conf.h
  group Interfaces
    ../Modules/: Track.h Avoid.h Ultrasound.h
    ../Drivers/: Motor.h Encoder.h Imu.h Heading.h
  group Hardware
    ../Hardware/: Avoid.c track.c Ultrasound.c Motor.c Encoder.c Imu.c Heading.c
  group Platform
    ../Platform/: Platform_stm32.c Platform.h
  group CMSIS
    ../Startup/: startup_stm32f10x_md.s
    ../Libraries/CMSIS/: system_stm32f10x.c core_cm3.c
  group StdPeriph
    ../Libraries/STM32F10x_StdPeriph_Driver/src/: misc.c stm32f10x_adc.c stm32f10x_bkp.c stm32f10x_can.c stm32f10x_cec.c stm32f10x_crc.c stm32f10x_dac.c stm32f10x_dbgmcu.c stm32f10x_dma.c stm32f10x_exti.c stm32f10x_flash.c stm32f10x_fsmc.c stm32f10x_gpio.c stm32f10x_i2c.c stm32f10x_iwdg.c stm32f10x_pwr.c stm32f10x_rcc.c stm32f10x_rtc.c stm32f10x_sdio.c stm32f10x_spi.c stm32f10x_tim.c stm32f10x_usart.c stm32f10x_wwdg.c
